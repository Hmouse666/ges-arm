# Keil uVision project 22software_5.uvprojx, settings and files
target 22software_5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STMicroelectronics
  pack: Keil.stm32f1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 22software_5 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB
  c include: ../core/Inc;../drivers/stm32f1xx_hal_driver/Inc;../drivers/stm32f1xx_hal_driver/Inc/Legacy;../drivers/cmsis/device/ST/stm32f1xx/Include;../drivers/cmsis/Include;../tkkc_drivers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/core
    ../core/Src/: app.c main.c gpio.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group drivers/stm32f1xx_hal_driver
    ../drivers/stm32f1xx_hal_driver/Src/: stm32f1xx_ll_gpio.c stm32f1xx_ll_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group drivers/cmsis
    ../core/Src/: system_stm32f1xx.c
  group tkkc_drivers
    ../tkkc_drivers/: tkkc_font.c tkkc_st7735.c display.h display.c task_mode.h task_mode.c task1.h task1.c task2.h task2.c task3.h task3.c task4.h task4.c slider_mode.h slider_mode.c pca9685.h pca9685.c servo.h servo.c key.h key.c led.h led.c w25q64.c w25q64.h mpu6050.c mpu6050.h motor.h motor.c gesture_motor.h gesture_motor.c claw_servo.h claw_servo.c
software components: cmsis:core 4.3.0
